## Kconfig
```kconfig
config RTL8822EU
	tristate "Realtek 8822E USB WiFi"
	depends on USB
	select WIRELESS_EXT
	help
	  Help message of RTL8812AU
```
